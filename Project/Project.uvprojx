# Keil uVision project Project.uvprojx, settings and files
target GD32E23x (6220000::V6.22::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.2.3.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: .\CMSIS;.\CMSIS\GD\GD32E23x\Include;.\Lib\inc;.\Lib\SEGGER_RTT_V7.88i;.\Basic\SysTick;.\User\main;.\User\int;.\Basic\RCU;.\Hardware\TFT_LCD;.\Lib\SEGGER_RTT_V7.88i;.\Basic\Hardware_SPI;.\Basic\Software_IIC;.\Hardware\NorFlash_25Q;.\Hardware\TMP112;.\Hardware\SW351x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ./CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
    ./CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group Lib
    ./Lib/src/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Basic
    ./Basic/SysTick/: systick.c
    ./Basic/RCU/: RCU.c
    ./Basic/Hardware_SPI/: Hardware_SPI.c
    ./Basic/Software_IIC/: Software_IIC.C
  group Hardware
    ./Hardware/TFT_LCD/: TFT_LCD.c
    ./Hardware/NorFlash_25Q/: NorFlash_25Q.c
    ./Hardware/TMP112/: TMP112.c
  group User
    ./User/main/: main.c animation_demo.c
software components: CMSIS:CORE 5.5.0
